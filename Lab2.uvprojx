# Keil uVision project Lab2.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab2
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Objects
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c PLL.c TExaS.h lcd.c lcd.h keypad.c calc.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
